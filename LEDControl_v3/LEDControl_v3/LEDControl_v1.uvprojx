# Keil uVision project LEDControl_v1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LEDControl_v1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\HAL\button;.\APP;.\HAL\led;.\LIB;.\main;.\MCAL\nvic;.\MCAL\gpio;.\MCAL\systick;.\SERV;.\MCAL\gpt;.\SERV\pwm_manager
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./APP/: app.c
  group HAL
    ./HAL/led/: led_program.c
    ./HAL/button/: button_program.c
  group MCAL
    ./MCAL/gpio/: gpio_program.c
    ./MCAL/systick/: systick_program.c
    ./MCAL/gpt/: gpt_program.c
  group main
    ./main/: main.c
  group SERV
    ./SERV/pwm_manager/: pwm_program.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
